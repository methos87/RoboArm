Commit message: 240404

File: urdf/robot_assembly(moveit).urdf (robot description, URDF)
Before this commit: robot robo_arm, 7 links, 6 joints
Joints:
- joint Joint_5: origin xyz=-0.0002 0.059362 -0.0026 rpy=-1.6304 0 -1.5708 -> xyz=-0.0002 0.059362 -0.0026 rpy=-1.6304 0 1.5708
